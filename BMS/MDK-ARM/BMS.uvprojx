# Keil uVision project BMS.uvprojx, settings and files
target BMS (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: BMS +hex
  c flags: OneElfS=1 uC99=1 v6Lang=4 v6LangP=4 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../USER/BSP;../USER/DRV;../USER/TASK;../USER/MODBUS;../RTT;../lib
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c i2c.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group Drv
    ../USER/DRV/: drv_led.c drv_bq78350.c drv_key.c drv_rgb.c
  group Bsp
    ../USER/BSP/: bsp_smbus.c bsp_usart.c
  group Task
    ../USER/TASK/: bqRead_task.c systemState_task.c
  group lib
    ../lib/: crc.c
software components: CMSIS:CORE 5.6.0
